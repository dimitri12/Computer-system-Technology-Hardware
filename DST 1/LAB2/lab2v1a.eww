<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\lab2v1a.ewp</path>
  </project>
  <batchBuild/>
</workspace>


